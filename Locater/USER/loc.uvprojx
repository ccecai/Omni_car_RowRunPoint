# Keil uVision project loc.uvprojx, settings and files
target Locator (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\CAN;..\HARDWARE\TIM;..\HARDWARE\FILTER;..\HARDWARE\XV7011;..\HARDWARE\SPI;..\HARDWARE\ENCODER;..\HARDWARE\LOCATOR;..\DSP\inc;..\DSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/XV7011/: xv7011.c
    ../HARDWARE/FILTER/: filter.c
    ../HARDWARE/SPI/: bsp_spi.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/LOCATOR/: locator.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
